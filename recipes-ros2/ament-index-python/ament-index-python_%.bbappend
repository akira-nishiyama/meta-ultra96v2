FILES_${PN} += "*"
