
FILES_${PN} += "*"
