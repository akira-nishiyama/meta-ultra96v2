
EXTRA_OEMAKE_append_ultra96v2-zynqmp = " ${extra_settings} PRELOADED_BL33_BASE=${atf_bl33_load}"
ATF_CONSOLE_ultra96v2-zynqmp = "cadence1"
atf_bl33_load_ultra96v2-zynqmp = "0x10080000"

